FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += " file://dev_id.json \
           "