FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += " \
    file://.config \
    file://autoconfig.h \
    file://config.h \
    file://config_bl.h \
"
